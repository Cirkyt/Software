# IAR project ble_app_hrs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51822-QFAA NordicSemi nRF51822-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NRF51; DEBUG_NRF_USER; BOARD_NRF6310; BLE_STACK_SUPPORT_REQD; S110
  ICCARM.CCDiagSuppress: Pe301,Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\Include\app_common; ..\..\..\..\..\Include\ble; ..\..\..\..\..\Include\ble\softdevice; ..\..\..\..\..\Include\ble\ble_services; ..; ..\..\..\..\..\Include; $TOOLKIT_DIR$\CMSIS\Include; ..\..\..\..\..\Include\sd_common; ..\..\..\..\..\Include\s110; ..\..\..\..\..\Include\sdk; ..\..\..\..\..\Include\bootloader_dfu; ..\..\..\..\..\Include\ble\device_manager
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ble_app_hrs.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ble_app_hrs.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NRF51; BOARD_NRF6310; S110
  ICCARM.CCIncludePath2: ..\..\..\..\..\Include\app_common; ..\..\..\..\..\Include\ble; ..\..\..\..\..\Include\ble\softdevice; ..\..\..\..\..\Include\ble\ble_services; ..; ..\..\..\..\..\Include; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.5-EWARM-6.60.2.5464-BETA\arm\CMSIS\Include
  OBJCOPY.OOCOutputFile: iar_ble_app_hrs.hex
  group Libraries
    ../../../../../Source/app_common/: app_timer.c crc16.c pstorage.c
    ../../../../../Source/ble/: ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c ble_error_log.c ble_flash.c ble_radio_notification.c ble_sensorsim.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/ble/device_manager/: device_manager_peripheral.c
    ../: inv_mpu_dmp_motion_driver.c ml_math_func.c mpu9250.c
    ../../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/twi_master/: twi_hw_master.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_bas.c ble_dis.c ble_hrs.c
  group Source Code
    ../: main.c
  group Startup Code
    ../../../../../Source/templates/iar/: iar_startup_nrf51.s
    ../../../../../Source/templates/: system_nrf51.c
