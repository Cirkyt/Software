<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Libraries</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\app_common\app_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\ble\ble_advdata.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\ble\ble_conn_params.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\ble\ble_debug_assert_handler.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\ble\ble_error_log.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\ble\ble_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\ble\ble_radio_notification.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\ble\ble_sensorsim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\ble\ble_services\ble_srv_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\app_common\crc16.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\ble\device_manager\device_manager_peripheral.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\inv_mpu_dmp_motion_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\ml_math_func.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\mpu9250.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\nrf_delay\nrf_delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\app_common\pstorage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\sd_common\softdevice_handler.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\twi_master\twi_hw_master.c</name>
    </file>
  </group>
  <group>
    <name>Services</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\ble\ble_services\ble_bas.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\ble\ble_services\ble_dis.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\ble\ble_services\ble_hrs.c</name>
    </file>
  </group>
  <group>
    <name>Source Code</name>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
  </group>
  <group>
    <name>Startup Code</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\templates\iar\iar_startup_nrf51.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Source\templates\system_nrf51.c</name>
    </file>
  </group>
</project>


